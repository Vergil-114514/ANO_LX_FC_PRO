# Keil uVision project ANO_LX_STM32F429.uvprojx, settings and files
target Ano_LX (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ANO_LX +hex
  AfterMake: fromelf.exe --bin -o ./ANO-LX.bin ./build/Ano_LX.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,CONFIG_USB_DWC2_PORT=FS_PORT
  c misc: --c99
  c include: .\build;..\FcSrc;..\DriversBsp;..\DriversMcu\STM32F4xx\Drivers;..\DriversMcu\STM32F4xx\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\DriversMcu\STM32F4xx\Libraries\CMSIS\Include;..\DriversMcu\STM32F4xx\Libraries\CMSIS\ST\STM32F4xx\Include;..\DriversMcu\STM32F4xx;..\FcSrc\AnoPTv8;..\DriversMcu\STM32F4xx\cherryusb
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group FcSrc
    ../FcSrc/: SysConfig.h main.c Ano_Scheduler.c Ano_Scheduler.h User_Task.c User_Task.h DataTransfer.c DataTransfer.h LX_ExtSensor.c LX_ExtSensor.h LX_FcFunc.c LX_FcFunc.h LX_FcState.c LX_FcState.h LX_LowLevelFunc.c LX_LowLevelFunc.h
  group AnoPTv8
    ../FcSrc/AnoPTv8/: AnoPTv8.h AnoPTv8ExAPI.c AnoPTv8ExAPI.h AnoPTv8Run.c AnoPTv8Run.h AnoPTv8Cmd.c AnoPTv8Cmd.h AnoPTv8Par.c AnoPTv8Par.h AnoPTv8FrameFactory.c AnoPTv8FrameFactory.h
  group DriversBsp
    ../DriversBsp/: Drv_BSP.c Drv_BSP.h Ano_Math.c Ano_Math.h Drv_AnoOf.c Drv_AnoOf.h Drv_UbloxGPS.c Drv_UbloxGPS.h Drv_UwbMini5.c Drv_UwbMini5.h Drv_CarLink.c Drv_CarLink.h Drv_PayloadServo.c Drv_PayloadServo.h DrvAnoOF_ptv7.c DrvAnoOF_ptv7.h DrvIna228.c DrvIna228.h DrvIna3221.c DrvIna3221.h
  group DriversMcu
    ../DriversMcu/STM32F4xx/: McuConfig.h
    ../DriversMcu/STM32F4xx/Drivers/: stm32f4xx_it.c stm32f4xx_conf.h Drv_Sys.c Drv_Sys.h Drv_led.c Drv_led.h Drv_Timer.c Drv_Timer.h Drv_Uart.c Drv_Uart.h Drv_PwmOut.c Drv_PwmOut.h Drv_Dshot600.c Drv_Dshot600.h Drv_RcIn.c Drv_RcIn.h Drv_Usb.c Drv_Usb.h Drv_Adc.c Drv_Adc.h Drv_Buzzer.c Drv_Buzzer.h Drv_SI2c.c Drv_SI2c.h
  group LibrariesMcu
    ../DriversMcu/STM32F4xx/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../DriversMcu/STM32F4xx/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
    ../DriversMcu/STM32F4xx/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group LibrariesMcu/cherryusb
    ../DriversMcu/STM32F4xx/cherryusb/: usb_dc_dwc2.c usbd_cdc.c usbd_core.c
  group Doc
    ../Doc/: note.txt
